<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>remotecar_RemoteCarIIBaseBand</key>
<param><key>id</key><value>remotecar_RemoteCarIIBaseBand_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>run</key><value>True</value></param>
<param><key>command</key><value>99</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>27.15e6</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>if_gain0</key><value>50</value></param>
<param><key>bb_gain0</key><value>30</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>example_tx_II_with_geosson_gui</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>remotecar_RemoteCarIIBaseBand_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>remotecar_RemoteCarIIBaseBand_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
